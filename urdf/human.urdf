Commit message: fix: Cylinder dimensions must be non-negative.

File: urdf/human.urdf (robot description, URDF)
Before this commit: robot human_model, 44 links, 43 joints
Links:
- link human/base: geometry visual cylinder length=0.0811138121076 radius=0.130553532998
